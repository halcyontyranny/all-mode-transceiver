options:
  parameters:
    author: Chris Mack - KF0UXU
    comment: Multimode Transceiver by KF0UXU
    description: Multimode Signal Generator / Receiver
    generate_options: qt_gui
    id: HackRFMultiModeTransceiver
    output_language: python
    title: Multimode Transceiver by KF0UXU
  states: {}

blocks:
- name: AM_band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '0.5'
    high_cutoff_freq: '3200'
    low_cutoff_freq: '-3200'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: DSB_band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    comment: Filters have different bandwidth and gain based on mode.
    gain: '1'
    high_cutoff_freq: '3200'
    low_cutoff_freq: '-3200'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: FM_band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '10000'
    low_cutoff_freq: '-10000'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: LSB_band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '2.0'
    high_cutoff_freq: '-150'
    low_cutoff_freq: '-side_band_width'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '75'
    win: window.WIN_HAMMING
  states: {}
- name: USB_band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    comment: About 75db other SB suppression on 1khz tone
    gain: '2.0'
    high_cutoff_freq: side_band_width
    low_cutoff_freq: '150'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '75'
    win: window.WIN_HAMMING
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: Frequency(MHz)
    type: real
    value: '75'
  states: {}
- name: freq_correction
  id: variable_qtgui_range
  parameters:
    comment: Freq correction 3,1,1,1
    gui_hint: 3,1,1,1
    label: Frequency Correction (PPM)
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: mc
  id: variable_qtgui_chooser
  parameters:
    comment: 2,0,1,1
    gui_hint: 2,0,1,1
    label: Mod Content
    labels: '["WaveFile","WaveFile + PL Tone", "Tone", "Tone + PL Tone", "Mic", "Mic + PL Tone", "None"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5,6]'
    type: int
    value: '0'
  states: {}
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: Mic Gain
    min_len: '100'
    start: '0.0'
    step: '0.1'
    stop: '1'
    value: '1.0'
  states: {}
- name: mod
  id: variable_qtgui_chooser
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: Modulation Type
    labels: '["LSB", "USB", "DSB", "AM", "FM5K", "WFM"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5]'
    orient: Qt.QHBoxLayout
    type: int
    value: '4'
    widget: radio_buttons
  states: {}
- name: output_amp
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 2,1,1,1
    initPressed: 'False'
    label: HackRF Base Amp
    pressBackgroundColor: green
    pressed: '14'
    relBackgroundColor: red
    relFontColor: green
    released: '0'
    type: int
    value: '0'
  states: {}
- name: output_lvl
  id: variable_qtgui_range
  parameters:
    comment: 3,0,1,1
    gui_hint: 3,0,1,1
    label: Output Level
    min_len: '100'
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '24'
  states: {}
- name: pl_freq
  id: variable_qtgui_chooser
  parameters:
    comment: 2,2,1,1
    gui_hint: 2,2,1,1
    label: PL Tone
    labels: '["67.0", "71.9", "74.4", "77.0", "79.7", "82.5", "85.4", "88.5", "91.5", "94.8", "97.4", "100.0", "103.5", "107.2", "110.9", "114.8", "118.8", "123.0", "127.3", "131.8", "136.5", "141.3", "146.2", "151.4", "156.7", "162.2", "167.9", "173.8", "179.9", "186.2", "192.8", "203.5", "210.7", "218.1", "225.7", "233.6", "241.8", "250.3"]'
    num_opts: '0'
    options: '[67.0, 71.9, 74.4, 77.0, 79.7, 82.5, 85.4, 88.5, 91.5, 94.8, 97.4, 100.0, 103.5, 107.2, 110.9, 114.8, 118.8, 123.0, 127.3, 131.8, 136.5, 141.3, 146.2, 151.4, 156.7, 162.2, 167.9, 173.8, 179.9, 186.2, 192.8, 203.5, 210.7, 218.1, 225.7, 233.6, 241.8, 250.3]'
    type: real
    value: '141.3'
  states: {}
- name: pl_level
  id: variable
  parameters:
    comment: |-
      Adj for ~650hz fm deviation
      0.130=1/(5000/650)
    value: '0.130'
  states: {}
- name: ptt
  id: variable_qtgui_push_button
  parameters:
    label: Push To Talk
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: rx_bb_gain
  id: variable_qtgui_range
  parameters:
    comment: 5,1,1,1
    gui_hint: 5,1,1,1
    label: RX BB Gain (dB)
    min_len: '100'
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '16'
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    comment: 5,0,1,1
    gui_hint: 5,0,1,1
    label: RX IF Gain (dB)
    min_len: '100'
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: rx_volume
  id: variable_qtgui_range
  parameters:
    comment: 5,2,1,1
    gui_hint: 5,2,1,1
    label: RX Volume
    min_len: '100'
    start: '0'
    step: '0.05'
    stop: '2.0'
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: side_band_width
  id: variable_qtgui_chooser
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    label: Side Band Width
    labels: '[''300 Hz'', ''400 Hz'', ''600 Hz'', ''850 Hz'', ''1100 Hz'', ''1200 Hz'', ''1500 Hz'', ''1650 Hz'', ''1800 Hz'', ''1950 Hz'', ''2100 Hz'', ''2250 Hz'', ''2400 Hz'', ''2450 Hz'', ''2500 Hz'', ''2600 Hz'', ''2700 Hz'', ''2800 Hz'', ''2900 Hz'', ''3000 Hz'', ''3200 Hz'', ''3500 Hz'', ''4000 Hz'']'
    num_opts: '0'
    options: '[300.0,400.0,600.0,850.0,1100.0,1200.0,1500.0,1650.0,1800.0,1950.0,2100.0,2250.0,2400.0,2450.0,2500.0,2600.0,2700.0,2800.0,2900.0,3000.0,3200.0,3500.0,4000.0]'
    type: real
    value: '3000.0'
  states: {}
- name: tone
  id: variable_qtgui_entry
  parameters:
    comment: 1,2,1,1
    gui_hint: 1,2,1,1
    label: Tone(Hz)
    type: int
    value: '1000'
  states: {}
- name: wavefile
  id: variable_qtgui_entry
  parameters:
    comment: 1,1,1,1
    gui_hint: 1,1,1,1
    label: Wavefile
    type: string
    value: /home/halcyon/Downloads/gc.wav
  states: {}
- name: wfm_active
  id: variable
  parameters:
    value: 1 if mod == 5 else 0
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    comment: RX FM demod
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    comment: FM modulation path
    fh: '-1'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: mic_gain
    comment: |-
      Amplitude of 1 results in the max 
      deviation setup in the NBFM
      transmit block or 100% modulation
      in the other modes.
    freq: tone
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: pl_level
    comment: PL is 650hz dev
    freq: pl_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    comment: RX WFM demod — 480k→48k audio
    quad_rate: '480000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    comment: TX WFM modulator — 48k audio → 480k complex
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_rx_am
  id: blocks_complex_to_mag
  parameters:
    comment: RX AM envelope detection
  states: {}
- name: blocks_complex_to_real_rx_dsb
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_rx_lsb
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_rx_usb
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Convert to DSB or AM
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mic Gain
    const: mic_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: adj for pl+wav
    const: 1.0/(1.0+pl_level)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: adj for pl+tone
    const: 1.0/(1.0+pl_level)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: adj for pl+wav
    const: 1.0/(1.0+pl_level)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: mic_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_rx_vol
  id: blocks_multiply_const_vxx
  parameters:
    comment: RX Volume
    const: rx_volume
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    comment: |-
      No Modulation or
      possible input from 
      line in or system microphone
    type: float
  states: {}
- name: blocks_null_source_wfm
  id: blocks_null_source
  parameters:
    comment: Dummy 6th input for TX modulation selector
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: Select Baseband Modulation
    enabled: 'True'
    input_index: mod
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    comment: AM carrier insertion
    enabled: 'True'
    input_index: mod
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    comment: Select Modulation Content
    enabled: 'True'
    input_index: mc
    num_inputs: '7'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_rx
  id: blocks_selector
  parameters:
    comment: Select RX Demodulation
    enabled: 'True'
    input_index: mod
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_tx_out
  id: blocks_selector
  parameters:
    comment: Route narrow-band or WFM TX to transceiver
    enabled: 'True'
    input_index: wfm_active
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Voice,1kHz,DTMF @ 48kHz
    file: wavefile
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_rx_am
  id: dc_blocker_xx
  parameters:
    comment: Remove AM carrier DC offset regardless of signal amplitude
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: Isolate LSB
    decim: '1'
    taps: LSB_band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    comment: Isolate USB
    decim: '1'
    taps: USB_band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    comment: Isolate DSB
    decim: '1'
    taps: DSB_band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0
  id: fft_filter_xxx
  parameters:
    comment: Isolate AM
    decim: '1'
    taps: AM_band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0_0_0
  id: fft_filter_xxx
  parameters:
    comment: Isolate FM
    decim: '1'
    taps: FM_band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_rx_am
  id: fft_filter_xxx
  parameters:
    comment: RX Isolate AM
    decim: '1'
    taps: AM_band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_rx_dsb
  id: fft_filter_xxx
  parameters:
    comment: RX Isolate DSB
    decim: '1'
    taps: DSB_band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_rx_lsb
  id: fft_filter_xxx
  parameters:
    comment: RX Isolate LSB
    decim: '1'
    taps: LSB_band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_rx_usb
  id: fft_filter_xxx
  parameters:
    comment: RX Isolate USB
    decim: '1'
    taps: USB_band_pass_filter_taps
    type: ccc
  states: {}
- name: osmosdr_transceiver_0
  id: osmosdr_transceiver
  parameters:
    args: '"hackrf=0"'
    bandwidth: '0'
    center_freq: freq * 1e6
    comment: |-
      tx gains: RF 0,14 and TX IF 0..47
      RF=14 and TX IF=39 is about 1mw
      RF=14 and TX IF=20 is about 20uw
      HackRF likes sample rates of 8,10,12.5,16 or 20MHz.
    freq_corr: freq_correction
    rf_gain: output_amp
    rx_bb_gain: rx_bb_gain
    rx_if_gain: rx_if_gain
    sample_rate: '8000000'
    transmit: ptt
    tx_gain: output_lvl
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/1
    comment: Spectrum View 4,1,1,1
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '16384'
    gui_hint: 4,1,1,1
    label: TX Drive Spectrum
    label1: IF Spectrum
    legend: 'False'
    type: complex
    width1: '2'
    ymax: '0'
    ymin: '-200'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Scope View 4,0,1,1
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 4,0,1,1
    legend: 'False'
    size: '16384'
    srate: samp_rate
    type: float
    ylabel: TX IQ Drive Amplitude
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Waterfall View 4,2,1,1
    fc: freq*1e6
    fftsize: '16384'
    gui_hint: 4,2,1,1
    label1: TX Waterfall
    name: TX Waterfall
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '1024'
    label1: RX Waterfall
    name: RX Waterfall
    type: complex
  states: {}
- name: rational_resampler_wfm_rx_0
  id: rational_resampler_xxx
  parameters:
    comment: resample from 8M to 480k for WFM RX
    decim: '100'
    fbw: '4e-3'
    interp: '6'
    type: ccf
  states: {}
- name: rational_resampler_wfm_tx_0
  id: rational_resampler_xxx
  parameters:
    comment: resample from 480k to 8M for WFM TX
    decim: '3'
    fbw: '4e-3'
    interp: '50'
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: resample from 48k to 8M
    decim: '3'
    fbw: '4e-3'
    interp: '500'
    type: ccf
  states: {}
- name: rational_resampler_xxx_rx_0
  id: rational_resampler_xxx
  parameters:
    comment: resample from 8M to 48k
    decim: '500'
    fbw: '4e-3'
    interp: '3'
    type: ccf
  states: {}
- name: dc_blocker_cc_rx_0
  id: dc_blocker_xx
  parameters:
    comment: Remove HackRF IQ DC offset (eliminates center-frequency red line on waterfall)
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: ptt_gate_tx_displays
  id: blocks_selector
  parameters:
    comment: Pass TX signal to displays only while PTT is active
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: ptt
    type: complex
  states: {}
- name: blocks_null_sink_tx_disp
  id: blocks_null_sink
  parameters:
    comment: Drain TX display path when PTT is off
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import os
      os.environ["XDG_SESSION_TYPE"] = "xcb"
    section: main_after_init
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '"Audio Modulation"'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: Modulation sources generated/selected below
    stream_id: '"Audio Modulation"'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_0_0, '0', blocks_selector_0_0, '0']
- [analog_const_source_x_0_0, '0', blocks_selector_0_0, '1']
- [analog_const_source_x_0_0, '0', blocks_selector_0_0, '2']
- [analog_const_source_x_0_0, '0', blocks_selector_0_0, '4']
- [analog_const_source_x_0_0, '0', blocks_selector_0_0, '5']
- [analog_const_source_x_0_0_0, '0', blocks_selector_0_0, '3']
- [analog_nbfm_rx_0, '0', blocks_selector_rx, '4']
- [analog_nbfm_tx_0, '0', fft_filter_xxx_0_0_0_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_selector_0_1, '2']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_1, '0']
- [analog_wfm_rcv_0, '0', blocks_selector_rx, '5']
- [analog_wfm_tx_0, '0', rational_resampler_wfm_tx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_0, '0', blocks_selector_0_1, '1']
- [blocks_add_xx_0_0, '0', blocks_selector_0_1, '3']
- [blocks_add_xx_0_1, '0', blocks_float_to_complex_0, '1']
- [blocks_add_xx_1, '0', blocks_selector_0_1, '5']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_rx_am, '0', dc_blocker_xx_rx_am, '0']
- [blocks_complex_to_real_rx_dsb, '0', blocks_selector_rx, '2']
- [blocks_complex_to_real_rx_lsb, '0', blocks_selector_rx, '0']
- [blocks_complex_to_real_rx_usb, '0', blocks_selector_rx, '1']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0, '0']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0_0, '0']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0_0_0, '0']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_selector_0_1, '4']
- [blocks_multiply_const_vxx_rx_vol, '0', audio_sink_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_1, '6']
- [blocks_null_source_wfm, '0', blocks_selector_0, '5']
- [blocks_selector_0, '0', ptt_gate_tx_displays, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [ptt_gate_tx_displays, '0', blocks_null_sink_tx_disp, '0']
- [ptt_gate_tx_displays, '1', blocks_complex_to_float_0, '0']
- [ptt_gate_tx_displays, '1', qtgui_freq_sink_x_0, '0']
- [ptt_gate_tx_displays, '1', qtgui_waterfall_sink_x_0, '0']
- [blocks_selector_0_0, '0', blocks_add_xx_0_1, '0']
- [blocks_selector_0_1, '0', virtual_sink_0, '0']
- [blocks_selector_rx, '0', blocks_multiply_const_vxx_rx_vol, '0']
- [blocks_selector_tx_out, '0', osmosdr_transceiver_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [dc_blocker_xx_rx_am, '0', blocks_selector_rx, '3']
- [fft_filter_xxx_0, '0', blocks_selector_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_selector_0, '1']
- [fft_filter_xxx_0_0_0, '0', blocks_selector_0, '2']
- [fft_filter_xxx_0_0_0_0, '0', blocks_selector_0, '3']
- [fft_filter_xxx_0_0_0_0_0, '0', blocks_selector_0, '4']
- [fft_filter_xxx_rx_am, '0', blocks_complex_to_mag_rx_am, '0']
- [fft_filter_xxx_rx_dsb, '0', blocks_complex_to_real_rx_dsb, '0']
- [fft_filter_xxx_rx_lsb, '0', blocks_complex_to_real_rx_lsb, '0']
- [fft_filter_xxx_rx_usb, '0', blocks_complex_to_real_rx_usb, '0']
- [osmosdr_transceiver_0, '0', rational_resampler_wfm_rx_0, '0']
- [osmosdr_transceiver_0, '0', rational_resampler_xxx_rx_0, '0']
- [rational_resampler_wfm_rx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_wfm_tx_0, '0', blocks_selector_tx_out, '1']
- [rational_resampler_xxx_0_0_0_0, '0', blocks_selector_tx_out, '0']
- [rational_resampler_xxx_rx_0, '0', dc_blocker_cc_rx_0, '0']
- [dc_blocker_cc_rx_0, '0', analog_nbfm_rx_0, '0']
- [dc_blocker_cc_rx_0, '0', fft_filter_xxx_rx_am, '0']
- [dc_blocker_cc_rx_0, '0', fft_filter_xxx_rx_dsb, '0']
- [dc_blocker_cc_rx_0, '0', fft_filter_xxx_rx_lsb, '0']
- [dc_blocker_cc_rx_0, '0', fft_filter_xxx_rx_usb, '0']
- [dc_blocker_cc_rx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [virtual_source_0, '0', analog_nbfm_tx_0, '0']
- [virtual_source_0, '0', analog_wfm_tx_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0_1, '1']

metadata:
  file_format: 1
